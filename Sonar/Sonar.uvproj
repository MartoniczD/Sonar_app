# Keil uVision project Sonar.uvproj, settings and files
target STM32F303VC (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Sonar
  c flags: Optim=1
  c include: ApplicationLayer;.\ComplexDrivers;.\InterruptDispatcher;.\MicrocontrollerAbsLayer;.\Startup;.\MicrocontrollerAbsLayer\CMSIS;.\ECUAbstraction
  asm include: ApplicationLayer
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT5: ROM 0x1fff7fac size 0x20
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Startup
    ./Startup/: startup_stm32f30x_arm.s
  group ApplicationLayer
    ./ApplicationLayer/: main.c
  group ComplexDrivers
    ./ComplexDrivers/: CD_AnalogIn.c CD_Delay.c CD_OPAMP.c CD_AnalogOut.c CD_UniqueID.c CD_NVM.c
  group InterruptDispatcher
    ./InterruptDispatcher/: stm32f30x_it.c
  group MicrocontrollerAbsLayer
    ./MicrocontrollerAbsLayer/: stm32f30x_adc.c stm32f30x_dac.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_rcc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_flash.c
  group MicrocontrollerAbsLayer_CMSIS
    ./MicrocontrollerAbsLayer/CMSIS/: system_stm32f30x.c
  group MicrocontrollerAbsLayer_CMSIS_LIB
    ./MicrocontrollerAbsLayer/CMSIS/LIB/: arm_cortexM0b_math.lib arm_cortexM0l_math.lib arm_cortexM3b_math.lib arm_cortexM3l_math.lib arm_cortexM4b_math.lib arm_cortexM4bf_math.lib arm_cortexM4l_math.lib arm_cortexM4lf_math.lib
  group ECUAbstraction
    ./ECUAbstraction/: ECUA_HMI.c ECUA_SerialComm.c
